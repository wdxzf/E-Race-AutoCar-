# Keil uVision project SeekFree_MSPM0G3507_Device_Library.uvprojx, settings and files
target SeekFree_MSPM0G3507_Device_Library (6160000::V6.16::ARMCLANG)
  device: MSPM0G3507 Texas Instruments
  pack: TexasInstruments.MSPM0G1X0X_G3X0X_DFP.1.3.1
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20200000,0x00008000) IROM(0x00000000,0x00020000) IROM2(0x00400000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SeekFree_MSPM0G3507_Device_Library +hex
  BeforeMake: cmd.exe /C "$P../../../tools/keil/syscfg.bat '$P' SeekFree_MSPM0G3507_Device_Library.syscfg"
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=4
  c define: __MSPM0G3507__
  c include: ..\..\..\source\third_party\CMSIS\Core\Include;..\..\..\source;..\BSP;..\;..\zf_common;..\zf_device;..\zf_driver
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20200000 size 0x8000
  scatter file: .\mspm0g3507.sct
  group Source
    ../: SeekFree_MSPM0G3507_Device_Library.c SeekFree_MSPM0G3507_Device_Library.syscfg board.c board.h ti_msp_dl_config.c ti_msp_dl_config.h
    ./: startup_mspm0g350x_uvision.s
  group BSP
    ../BSP/: headfile.h motor.c motor.h Gray.h Gray.c A_imu66ra.c A_imu66ra.h My_PID.c My_PID.h hled_key.c hled_key.h encoder.c encoder.h
  group Driverlib
    ../ti/: dl_vref.c dl_uart.c dl_trng.c dl_timer.c dl_spi.c dl_rtc_common.c dl_opa.c dl_mcan.c dl_mathacl.c dl_lfss.c dl_lcd.c dl_keystorectl.c dl_i2c.c dl_flashctl.c dl_dma.c dl_dac12.c dl_crcp.c dl_crc.c dl_common.c dl_aesadv.c dl_aes.c dl_adc12.c
  group zf_common
    ../zf_common/: zf_common_debug.c zf_common_debug.h zf_common_function.c zf_common_function.h zf_common_typedef.h
  group zf_device
    ../zf_device/: zf_device_imu_interface.c zf_device_imu_interface.h zf_device_imu660ra.c zf_device_imu660ra.h
